# FreeBSD target tuples are intentionally not normalized to Linux ABI variants.
MODIFYTOS:freebsd = "0"
